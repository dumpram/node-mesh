# Keil uVision project nrf-mesh-api.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf-mesh-api +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF51 NRF51822
  c include: .\; .\Lib\components\proprietary_rf\esb; .\Lib\components\device
  asm define: NRF51 NRF51822
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ./: main_mesh_V2.c main_mesh_V2.h
  group ESBLib
    ./: ESB_lib_precompiled.lib
  group System
    ./Lib/components/toolchain/: system_nrf51.c system_nrf51.h
    ./Lib/components/toolchain/arm/: arm_startup_nrf51.s
  group Misc_Libs
    ./: ringbuf.c ringbuf.h
  group Mesh_Lib
    ./: node.c node.h radio-platform.c radio-platform.h node-radio.c node-radio.h
software components: CMSIS:CORE 5.0.0
